# Keil uVision project usbd_rom_msc_SD.uvproj, settings and files
target usbd_rom_msc_SD (ARM-ADS)
  device: LPC1549JBD64 NXP
  pack: Keil.LPC1500_DFP.1.0.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x02000000,0x9000) CPUTYPE("Cortex-M3") CLOCK(75000000) ELITTLE
  output: usbd_rom_msc_SD
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: .\inc;..\..\lib_lpc_chip_15xx\inc;..\..\lib_nxp_lpcxpresso_1549_board\inc;..\..\lib_delay_lpc15xx\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x9000
  group startup
    ./startup/: keil_startup_lpc15xx.s sysinit.c
  group inc
    ./inc/: app_usbd_cfg.h msc_usb.h sd_spi.h uart.h
  group src
    ./src/: msc_desc.c msc_main.c msc_user.c sd_spi.c uart.c
  group libs
    ../../lib_lpc_chip_15xx/obj/: lib_lpc_chip_15xx.lib
    ../../lib_nxp_lpcxpresso_1549_board/obj/: lib_nxp_lpcxpresso_1549_board.lib
    ../../lib_delay_lpc15xx/obj/: lib_delay_lpc15xx.lib
